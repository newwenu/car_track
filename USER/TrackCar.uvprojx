# Keil uVision project TrackCar.uvprojx, settings and files
target TrackCar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TrackCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Src\BSP\system;..\Src\BSP\sensor;..\Src\BSP\actuator;..\Src\BSP\display;..\Src\BSP\input;..\Src\APP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group CORE
    ./: system_stm32f10x.c stm32f10x_it.c
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group board
    ../Src/BSP/system/: board.c config.h
  group sensor
    ../Src/BSP/sensor/: trace.c encoder.c ultrasonic.c adc.c
  group actuator
    ../Src/BSP/actuator/: motor.c pwm.c buzzer.c led.c
  group display
    ../Src/BSP/display/: oledfont.h oled_spi.c
  group input
    ../Src/BSP/input/: key.c
  group APP
    ../Src/APP/: app.c
    ../Src/APP/dashboard/: ui_dashboard.c
    ../Src/APP/vehicle/: vehicle_state.c
    ../Src/APP/motion/: motion_control.c
